File: Hardware/hardware_v9/hardware v8/BTN_CONN.kicad_sch (KiCad schematic)
At the start: 16 parts, among them J2 503548-0622, J3 USB4110-GF-A

Commit message: up
Parts:
- U4: value ~ -> (none)
